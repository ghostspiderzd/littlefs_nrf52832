# Keil uVision project ble_app_volmeas_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  c include: ..\..\..\config\experimental_ble_app_blinky_pca10040_s132;..\..\..\config;..\..\..\..\components;..\..\..\..\components\ble\ble_advertising;..\..\..\..\components\ble\common;..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\components\ble\peer_manager;..\..\..\..\components\boards;..\..\..\..\components\drivers_nrf\adc;..\..\..\..\components\drivers_nrf\clock;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\drivers_nrf\power;..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\components\drivers_nrf\timer;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\components\libraries\bsp;..\..\..\..\components\libraries\button;..\..\..\..\components\libraries\fds;..\..\..\..\components\libraries\fstorage;..\..\..\..\components\libraries\gpiote;..\..\..\..\components\libraries\hardfault;..\..\..\..\components\libraries\led_softblink;..\..\..\..\components\libraries\log;..\..\..\..\components\libraries\log\src;..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\components\libraries\mem_manager;..\..\..\..\components\libraries\queue;..\..\..\..\components\libraries\scheduler;..\..\..\..\components\libraries\slip;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\uart;..\..\..\..\components\libraries\usbd;..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\components\libraries\usbd\config;..\..\..\..\components\libraries\util;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\softdevice\s132\headers;..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\components\toolchain;..\config;..\..\..\..\components\ble\ble_services\ble_volmeas;..\..\..\..\config;..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\components\libraries\twi;..\..\..\..\components\drivers_nrf\twi_master\deprecated;..\..\..\..\components\drivers_nrf\twi_master\deprecated\config;..\..\..\..\components\drivers_ext\mpu6050;..\arm5_no_packs;..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\components\ble\ble_services\ble_nus;..\arm5_no_packs;..\..\..\..\littlefs-master\littlefs-master;..\..\..\..\fatfs;..\..\..\..\fatfs\src;..\..\..\..\components\libraries\block_dev;..\..\..\..\fatfs\port;..\..\..\..\components\libraries\block_dev\sdc;..\..\..\..\components\libraries\sdcard;..\..\..\..\components\libraries\block_dev\sdc
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DSWI_DISABLE0
  asm include: ..\..\..\config\experimental_ble_app_blinky_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config;..\..\..\..\components\libraries\block_dev\sdc;..\..\..\..\components\libraries\block_dev;..\..\..\..\fatfs\port;..\..\..\..\fatfs\src;..\..\..\..\components\libraries\sdcard
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002a68 size 0xd598
  group Application
    ./: main.c
    ./: BLE_SET.c BLE_CRC.c ADS1292R.c MLX90615.c DATA_FILTER.c STM32SPI.c Flash_driver.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../components/boards/: boards.c
  group Board Support
    ../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group nRF_BLE
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_Services
    ../../../../components/ble/ble_services/ble_volmeas/: ble_volmeas.c
  group nRF_Drivers
    ../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../components/drivers_nrf/hal/: nrf_saadc.c
    ../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../components/drivers_ext/mpu6050/: mpu6050.c
    ../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../components/drivers_nrf/twi_master/deprecated/: twi_hw_master.c
    ../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Libraries
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../components/libraries/timer/: app_timer.c
    ../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_SoftDevice
    ../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group FATFS
    ../../../../fatfs/: fs_driver.c
    ../../../../fatfs/src/: ff.c
    ../../../../fatfs/port/: diskio_blkdev.c
  group LittleFS
    ../../../../littlefs-master/littlefs-master/: lfs.c lfs_util.c
    ./: fs_config.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\config\experimental_ble_app_blinky_pca10040_s132;..\..\..\config;..\config;..\..\..\..\components\libraries\util;..\..\..\..\components\toolchain\cmsis\include;..\..\..\..\components\softdevice\s132\headers;..\..\..\..\components\ble\common;..\..\..\..\components\serialization\application\transport;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\button;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\bsp;..\..\..\..\components\drivers_nrf\twi_master\deprecated;..\..\..\..\components\drivers_nrf\twi_master\deprecated\config;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\libraries\log;..\..\..\..\components\libraries\log\src
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config\experimental_ble_app_blinky_pca10040_s132;..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
